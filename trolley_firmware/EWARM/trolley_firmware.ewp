# IAR project trolley_firmware.ewp, settings and files
configuration STM32F429_439xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx
  ICCARM.CCIncludePath2: ..\; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\user; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Utilities\STM32_EVAL\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F427_437xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F437II ST STM32F437II
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F427_437xx; USE_STM324x7I_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL
configuration STM32F40_41xxx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F417IG ST STM32F417IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
configuration STM32F401xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401VC ST STM32F401VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common
configuration STM32F411xE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: as above
configuration STM32F446xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
configuration STM32F469_479xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F479NI ST STM32F479NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F469_479xx
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL
configuration STM32F410xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F410RB ST STM32F410RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F410xx
  ICCARM.CCIncludePath2: as above
configuration STM32F412xG (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F412ZG ST STM32F412ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F412xG
  ICCARM.CCIncludePath2: as above
configuration STM32F413_423xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F413ZH ST STM32F413ZH
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F413_423xx
  ICCARM.CCIncludePath2: as above
  group CMSIS
    $EW_DIR$/arm/src/flashloader/ST/FlashSTM32F4xx/inc/: stm32f4xx.h
    ../user/: system_stm32f4xx.c
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../user/: main.c stm32f4xx_it.c
